require gdb-fsl.inc

SRC_URI += "file://sim-install-6.6.patch"

DEPENDS += "flex-native bison-native"
