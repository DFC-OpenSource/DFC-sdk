require gcc-linaro-common-4.9.inc
require gcc-linaro-4.9.inc
require recipes-devtools/gcc/libgcc-initial.inc
