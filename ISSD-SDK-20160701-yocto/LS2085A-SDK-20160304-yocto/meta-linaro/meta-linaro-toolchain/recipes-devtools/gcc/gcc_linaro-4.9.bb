require gcc-linaro-common-4.9.inc
require recipes-devtools/gcc/gcc_${BASEPV}.bb

DEPENDS += "gmp-native"
