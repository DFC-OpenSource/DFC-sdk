require gcc-linaro-common-4.8.inc
require gcc-linaro-4.8.inc
require recipes-devtools/gcc/libgfortran.inc

