require gcc-linaro-common-4.9.inc
require recipes-devtools/gcc/gcc-crosssdk_${BASEPV}.bb
