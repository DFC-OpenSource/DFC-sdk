require gcc-linaro-common-4.9.inc
require recipes-devtools/gcc/gcc-cross-canadian_${BASEPV}.bb
