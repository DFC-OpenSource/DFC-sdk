BASEPV = "4.8"
PV = "linaro-${BASEPV}"
require recipes-devtools/gcc/gcc-cross_${BASEPV}.bb
