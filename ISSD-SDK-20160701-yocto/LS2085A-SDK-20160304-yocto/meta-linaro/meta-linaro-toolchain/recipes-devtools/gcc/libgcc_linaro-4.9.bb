require gcc-linaro-common-4.9.inc
require recipes-devtools/gcc/libgcc_${BASEPV}.bb
