require gcc-linaro-common-4.8.inc
require recipes-devtools/gcc/gcc-cross-canadian_${BASEPV}.bb
