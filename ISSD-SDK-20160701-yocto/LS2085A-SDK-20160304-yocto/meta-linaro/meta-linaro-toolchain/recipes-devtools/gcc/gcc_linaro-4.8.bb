require gcc-linaro-common-4.8.inc
require recipes-devtools/gcc/gcc_${BASEPV}.bb

DEPENDS += "gmp-native"
