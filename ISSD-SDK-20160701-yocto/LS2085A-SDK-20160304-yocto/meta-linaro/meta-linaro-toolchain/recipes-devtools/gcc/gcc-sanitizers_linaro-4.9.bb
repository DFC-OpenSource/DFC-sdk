require gcc-linaro-common-4.9.inc
require recipes-devtools/gcc/gcc-${PV}.inc
require recipes-devtools/gcc/gcc-sanitizers.inc
