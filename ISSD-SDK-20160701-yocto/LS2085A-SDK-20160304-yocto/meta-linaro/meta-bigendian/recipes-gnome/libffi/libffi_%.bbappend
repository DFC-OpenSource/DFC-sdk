FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://libffi_armeb_be8.patch"
