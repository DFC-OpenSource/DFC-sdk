SRC_URI_append_armeb = " file://arm/alignment.sh"
