FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://python_ffi_armeb_be8.patch"
