FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://strace-4.8-arm-be8.patch"
