require recipes-core/images/core-image-minimal.bb
require linaro-image-common.inc
