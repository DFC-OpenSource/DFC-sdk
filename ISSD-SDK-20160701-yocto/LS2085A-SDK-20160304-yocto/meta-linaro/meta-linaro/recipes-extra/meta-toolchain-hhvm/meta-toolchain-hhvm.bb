TOOLCHAIN_TARGET_TASK = "packagegroup-core-standalone-hhvm-sdk-target"
TOOLCHAIN_OUTPUTNAME = "${SDK_NAME}-toolchain-hhvm-${DISTRO_VERSION}"
PROVIDES = "meta-toolchain-sdk"
require recipes-core/meta/meta-toolchain.bb
