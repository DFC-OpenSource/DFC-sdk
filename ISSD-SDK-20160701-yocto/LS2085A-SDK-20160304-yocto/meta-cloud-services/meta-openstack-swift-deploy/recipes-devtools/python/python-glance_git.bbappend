# Force Glance to use Swift as backend store
GLANCE_DEFAULT_STORE = "swift"
