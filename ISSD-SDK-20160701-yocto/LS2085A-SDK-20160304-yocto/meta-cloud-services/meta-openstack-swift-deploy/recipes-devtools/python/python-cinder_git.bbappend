# Force Cinder Backup to use Swift as backend store
CINDER_BACKUP_BACKEND_DRIVER = "cinder.backup.drivers.swift"
