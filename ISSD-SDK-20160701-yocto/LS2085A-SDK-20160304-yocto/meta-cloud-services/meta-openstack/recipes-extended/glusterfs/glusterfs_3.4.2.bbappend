#
# Copyright (C) 2013 Wind River Systems, Inc.
#
inherit openstackchef


