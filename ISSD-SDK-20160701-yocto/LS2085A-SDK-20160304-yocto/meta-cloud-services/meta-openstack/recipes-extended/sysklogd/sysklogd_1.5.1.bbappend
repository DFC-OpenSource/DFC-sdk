#
# Copyright (C) 2014 Wind River Systems, Inc.
#

require recipes-extended/syslog/syslog-user.inc

