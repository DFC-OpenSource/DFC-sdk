DESCRIPTION = "Port of the Tulip project (asyncio module, PEP 3156) on Python 2"
HOMEPAGE = "https://pypi.python.org/pypi/trollius"
SECTION = "devel/python"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://COPYING;md5=8f7bb094c7232b058c7e9f2e431f389c"

SRC_URI[md5sum] = "5704231bc385660783c5fad59e75549d"
SRC_URI[sha256sum] = "a8e0e2d3a3193be3e0f113253f41675d2679d23c491f32b37f4e0a736f32a28f"

inherit pypi
