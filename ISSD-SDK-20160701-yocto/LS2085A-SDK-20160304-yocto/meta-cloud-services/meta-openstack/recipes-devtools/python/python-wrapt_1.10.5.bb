DESCRIPTION = "A Python module for decorators, wrappers and monkey patching."
HOMEPAGE = "https://pypi.python.org/pypi/wrapt/"
SECTION = "devel/python"
LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=848d45ec255e411c0ff82b034a49d8a0"

SRC_URI[md5sum] = "79732bbc096235704e7523d3bacd202c"
SRC_URI[sha256sum] = "99cbb4e3a3ea964df0cb1437261fc1198616ec872e7b501622f3f7f92fcd0833"

inherit pypi

