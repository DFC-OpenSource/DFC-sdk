DESCRIPTION = "An implementation of the JSON-RPC v2.0 specification as a client library."
HOMEPAGE = "https://pypi.python.org/pypi/jsonrpclib"
SECTION = "devel/python"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=cdbf8d74b765504fbdf8e154bb4458a1"

SRC_URI[md5sum] = "93382cff21aca9074896c9dc1c4ec73d"
SRC_URI[sha256sum] = "733dad5da783a6ff959927d8c77346273c3b377db43cbdae0bd833b64584cf3a"

inherit pypi

