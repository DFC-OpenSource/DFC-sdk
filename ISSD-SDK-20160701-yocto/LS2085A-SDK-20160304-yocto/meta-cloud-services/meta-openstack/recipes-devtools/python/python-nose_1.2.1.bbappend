# repair the install location to be site-packages/nose/*
inherit setuptools
