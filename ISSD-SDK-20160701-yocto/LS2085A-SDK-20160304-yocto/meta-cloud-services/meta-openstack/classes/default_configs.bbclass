OS_DEFAULT_INITSCRIPT_PARAMS ??= "defaults 30 10"
