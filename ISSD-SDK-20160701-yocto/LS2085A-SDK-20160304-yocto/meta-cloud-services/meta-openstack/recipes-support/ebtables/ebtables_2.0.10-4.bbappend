RRECOMMENDS_${PN} += " \
	kernel-module-ebtables \
	kernel-module-ebtable-nat \
	kernel-module-ebt-arp \
	kernel-module-ebt-ip \
	"

