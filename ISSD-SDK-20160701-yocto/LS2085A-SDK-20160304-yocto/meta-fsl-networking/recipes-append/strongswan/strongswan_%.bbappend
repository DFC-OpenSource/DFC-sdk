EXTRA_OECONF += " --enable-ctr \
    --enable-gcm \
    --enable-ccm \
"
