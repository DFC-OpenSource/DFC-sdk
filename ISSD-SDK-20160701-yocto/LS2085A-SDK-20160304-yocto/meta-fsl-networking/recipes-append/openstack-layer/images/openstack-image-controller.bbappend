IMAGE_INSTALL += "\
    apache2 \
    iscsi-initiator-utils \
    mariadb \
    memcached \
    merge-files \
    mysql-python \
    openstack-demo \
    packagegroup-cloud-compute \
    python-enum34 \
    python-psutil \
    rsync \
    xfsprogs \
    "
