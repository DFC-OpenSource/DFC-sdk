SWIG_FEATURES_aarch64 = "-D__LP64__"
