EXTRA_OEMAKE_append = " SUBDIRS='lib tc ip bridge'"
