DEPENDS += "xz"
PARALLEL_MAKE = ""
